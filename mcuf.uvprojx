# Keil uVision project mcuf.uvprojx, settings and files
target Cortex-M0 (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: mcuf_m0 (library)
  AfterMake: .keil\copy.bat mcuf_m0.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ../
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group macro
    ./macro/: package-info.h typename.h version.h
  group mcuf
    ./mcuf/: Allocator.h Ammeter.cpp Ammeter.h Array.h ArrayPrototype.cpp ArrayPrototype.h ArrayQueue.h ArrayQueuePrototype.cpp ArrayQueuePrototype.h BiConsumer.h BiConsumerEvent.h BlockPool.cpp BlockPool.h Boolean.cpp Boolean.h Buffer.h Byte.cpp Byte.h ByteBuffer.cpp ByteBuffer.h Character.cpp Character.h Closeable.h Collection.h CommandLineExecutor.cpp CommandLineExecutor.h CommandLineHandler.h CompletionHandler.h Console.h ConsoleSerialPort.cpp ConsoleSerialPort.h Consumer.h ConsumerEvent.h CoreThread.cpp CoreThread.h CoreTick.cpp CoreTick.h Data.cpp Data.h DuplexStream.h ErrorCode.h Executor.cpp Executor.h Fifo.cpp Fifo.h Function.h FunctionEvent.h Future.cpp Future.h InputBuffer.h InputBufferLimit.cpp InputBufferLimit.h InputStream.h InputStreamBuffer.h InputStreamHandler.cpp InputStreamHandler.h Integer.cpp Integer.h Interface.h InternetProtocolAddress.cpp InternetProtocolAddress.h Iterable.h Linked.h LinkedEntity.cpp LinkedEntity.h LinkedInputBuffer.cpp LinkedInputBuffer.h LinkedOutputBuffer.cpp LinkedOutputBuffer.h Map.h Maths.cpp Maths.h mcuf_base.h mcuf_param.h MediaAccessControlAddress.cpp MediaAccessControlAddress.h Memory.cpp Memory.h NioExecuteMethod.h Number.cpp Number.h Object.cpp Object.h OutputBuffer.h OutputBufferLimit.cpp OutputBufferLimit.h OutputStream.h OutputStreamBuffer.h OutputStreamHandler.cpp OutputStreamHandler.h package-info.h Pointer.cpp Pointer.h Pool.h PrintStream.cpp PrintStream.h Queue.h ReadonlyOutputBuffer.cpp ReadonlyOutputBuffer.h RingBuffer.cpp RingBuffer.h RingBufferInputStream.cpp RingBufferInputStream.h RingBufferOutputStream.cpp RingBufferOutputStream.h Runnable.h RunnableEntity.cpp RunnableEntity.h RunnableEvent.cpp RunnableEvent.h SerialBusQueue.cpp SerialBusQueue.h SerialBusStream.cpp SerialBusStream.h Short.cpp Short.h SocketAddress.cpp SocketAddress.h Stacker.cpp Stacker.h StreamSkipper.cpp StreamSkipper.h Strings.cpp Strings.h Supplier.h SupplierEvent.h System.cpp System.h SystemRegister.cpp SystemRegister.h TemperatureSensor.h Thread.cpp Thread.h ThreadEvent.cpp ThreadEvent.h ThreadPriority.h ThreadState.h Throwable.cpp Throwable.h Timer.cpp Timer.h TimerTask.cpp TimerTask.h TimerTick.cpp TimerTick.h Updater.h VirtualAnalogInputPin.cpp VirtualAnalogInputPin.h VirtualGeneralPin.cpp VirtualGeneralPin.h VirtualTemperatureSensor.cpp VirtualTemperatureSensor.h Voltmeter.cpp Voltmeter.h
  group hal
    ./hal/: AnalogInputPin.h AnalogInputPort.h AnalogInputPortControl.h Base.h EdgeTrigger.h EdgeTriggerControl.h EdgeTriggerEvent.h EdgeTriggerStatus.h FlashStorage.h FlashStorageControl.h FlashStorageEvent.h FlashStorageStatus.h GeneralInput.h GeneralOutput.h GeneralPin.h GeneralPinConfig.h GeneralPinControl.h GeneralPinMode.h GeneralPort.h GeneralPortControl.h InterruptEvent.h package-info.h PulseWidthPin.h PulseWidthPort.h PulseWidthPortControl.h SerialBus.h SerialBusControl.h SerialBusEvent.h SerialBusStatus.h SerialBusTransfer.h SerialPeriph.h SerialPeriphEvent.h SerialPeriphPacket.h SerialPeriphPhase.h SerialPeriphPolarity.h SerialPeriphSignificantBit.h SerialPeriphSlot.h SerialPeriphStatus.h SerialPeriphTransfer.h SerialPort.h SerialPortConfig.h SerialPortTransfer.h Timer.h TimerControl.h TimerEvent.h TimerStatus.h
  group rtos
    ./rtos/: InterfaceKernel.h InterfaceThread.h InterfaceTimer.h package-info.h
  group resources
    ./resources/: mcuf_config.h mcuf_lib.cpp
target Cortex-M3 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: mcuf_m3 (library)
  AfterMake: .keil\copy.bat mcuf_m3.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\mcuf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M4F (6180000::V6.18::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: mcuf_m4f (library)
  AfterMake: .keil\copy.bat mcuf_m4f.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\mcuf
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
