# Keil uVision project hal.uvprojx, settings and files
target hal (6160000::V6.16::ARMCLANG)
  device: -AT32F415RBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: hal (library)
  AfterMake: .keil\copy.bat bsp_arterytek_at32f415.lib
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F415RBT7
  c include: ..\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: AnalogInputPin.h AnalogInputPort.h AnalogInputPortControl.h Base.h EdgeTrigger.h EdgeTriggerControl.h EdgeTriggerEvent.h EdgeTriggerStatus.h FlashStorage.h FlashStorageControl.h FlashStorageEvent.h FlashStorageStatus.h GeneralInput.h GeneralOutput.h GeneralPin.h GeneralPinConfig.h GeneralPinControl.h GeneralPinMode.h GeneralPort.h GeneralPortControl.h InterruptEvent.h package-info.h PulseWidthPin.h PulseWidthPort.h PulseWidthPortControl.h SerialBus.h SerialBusControl.h SerialBusEvent.h SerialBusStatus.h SerialBusTransfer.h SerialPeriph.h SerialPeriphEvent.h SerialPeriphPacket.h SerialPeriphPhase.h SerialPeriphPolarity.h SerialPeriphSignificantBit.h SerialPeriphSlot.h SerialPeriphStatus.h SerialPeriphTransfer.h SerialPort.h SerialPortConfig.h SerialPortTransfer.h Timer.h TimerControl.h TimerEvent.h TimerStatus.h
